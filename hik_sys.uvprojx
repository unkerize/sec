# Keil uVision project hik_sys.uvprojx, settings and files
target hik_sys (5060528::V5.06 update 5 (build 528)::ARMCC)
  device: STM32F303CBTx STMicroelectronics
  pack: Keil.STM32F3xx_DFP.2.1.0
  cpu: IRAM(0x20000000,0x0000A000) IRAM2(0x10000000,0x00002000) IROM(0x08000000,0x00020000) CPUTYPE("Cortex-M4") FPU2 CLOCK(12000000) ELITTLE
  output: hik_sys +hex
  c flags: Optim=1 OneElfS=1 uC99=1 v6Lang=1 v6LangP=1 wLevel=2
  c define: STM32F303xB
  c include: .\core;.\core\drv;.\App;.\lib;.\units\decseg;.\units\flash;.\units\kbkey;.\units\nts;.\units\term;.\perif\gpio;.\perif\spi;.\perif\tim;.\perif\uart;.\perif\adc;.\units\ds
  asm define: STM32F303xB
  memory RVCT4: ROM 0x8000000 size 0x20000
  memory RVCT9: RAM 0x20000000 size 0xa000
  memory RVCT10: RAM 0x10000000 size 0x2000
  group App
    ./App/: app.c
  group Core
    ./core/: main.c system.c asm_unit.s
  group Libs
    ./lib/: crc.c
  group Perif
    ./perif/gpio/: gpio.c
  group Units
    ./units/decseg/: decseg.c
    ./units/kbkey/: kbkey.c
